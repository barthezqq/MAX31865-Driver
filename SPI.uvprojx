# Keil uVision project SPI.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MAX32625 Maxim
  pack: Maxim.MAX32625.1.1.0-a
  cpu: IRAM(0x20000000,0x00028000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET = MAX32625, TARGET_REV = 0x4132
  c misc: --diag_suppress=1295,1296 --library_type=microlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source Group 1
    ./: main.c max_spidrv.c max31865.c
software components: CMSIS:CORE 5.0.1, BSP:Board Support 1.1.0-a, Communications:I2C Master 1.1.0-a, Communications:SPI Master 1.1.0-a, Communications:SPI Slave 1.1.0-a, Communications:UART 1.1.0-a, Device:Startup 1.1.0-a, HAL:Hardware Access Layer 1.1.0-a, Peripherals:GPIO 1.1.0-a
